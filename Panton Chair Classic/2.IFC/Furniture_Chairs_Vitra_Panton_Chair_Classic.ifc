Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-24T14:24:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 24 14:24:55 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{5480DA26-939B-468E-A3F3-4AABF2177387}\ifc * Database version: 5507 * Database creation date: Wed Jun 24 14:24:54 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 24 14:24:55 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 24 14:24:55 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Panton Classic, Furniture_Chairs_Vitra_Panton_Chair_Classic:Panton Classic:332124
In: Level 1
Type - Material: 11 white
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Chairs_Vitra_Panton_Chair_Classic; ConvergoRefNr: 0089-2006-0024-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Having conceived a design for an all-plastic chair made from one piece, it took Verner Panton several years to find a manufacturer. He first came into contact with Vitra in 1963 and together they developed the Panton Chair, which was presented in 1967. It was hailed as a sensation and received numerous prizes. The original version of the chair with a glossy lacquer finish is still marketed today under the name Panton Chair Classic. Referring to the 50th anniversary of the Panton Chair, Marianne Panton talks about living with her husband, the creation of the chair icon and the two limited editions Panton Chrome and Panton Glow from 2018.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_48; Version: 1; VersionDate: 22/06/2020
Type - Identity Data(Type) - Collection: Panton; Cost: 0; Description: Having conceived a design for an all-plastic chair made from one piece, it took Verner Panton several years to find a manufacturer. He first came into contact with Vitra in 1963 and together they developed the Panton Chair, which was presented in 1967. It was hailed as a sensation and received numerous prizes. The original version of the chair with a glossy lacquer finish is still marketed today under the name Panton Chair Classic. Referring to the 50th anniversary of the Panton Chair, Marianne Panton talks about living with her husband, the creation of the chair icon and the two limited editions Panton Chrome and Panton Glow from 2018.; Designer: Verner Panton; Manufacturer: Vitra; Model: Panton Classic; OmniClass Number: 23.40.20.14.14.14; OmniClass Title: Settees, Sofas; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/177940/storage/master/download/FS_Panton_Chair-EN_Preview-Single-Page.pdf; Type Name: Panton Classic; URL: https://www.vitra.com/en-un/living/product/details/panton-chair-classic
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Chairs_Vitra_Panton_Chair_Classic; Features: n/a; Finish: Shell: rigid polyurethane foam. Surface: glossy lacquer finish.; Grade: n/a; Material: Rigid polyurethane foam; ModelNumber: n/a; ModelReference: n/a; Name: Vitra_Panton_Chair_Classic; ReplacementCost: n/a; Shape: Sculptured; Size: 500x610x830 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.15765 m2; Volume: 0.231318 m3
Materials and Finishes - ChairMainMaterial: 11 white
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Chairs_Vitra_Panton_Chair_Classic: Panton Classic; Family and Type: Furniture_Chairs_Vitra_Panton_Chair_Classic: Panton Classic; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Chairs_Vitra_Panton_Chair_Classic: Panton Classic; Type Id: Furniture_Chairs_Vitra_Panton_Chair_Classic: Panton Classic; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
